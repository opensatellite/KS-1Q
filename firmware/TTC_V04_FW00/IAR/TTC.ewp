# IAR project TTC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M2S010 Microsemi M2S010
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../hal; ../hal/CortexM3; ../hal/CortexM3/EWARM; ../CMSIS; ../CMSIS/startup_iar; ../drivers; ../; ../app; ../user_drivers; ../os/include; ../os/portable; ../usr_lib/libcsp/include; ..\usr_lib\DM
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../app
  OBJCOPY.OOCOutputFile: TTC.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Users\Administrator\Desktop\TTC\TTC\IAR\TTC2.icf
  ILINK.IlinkExtraOptions: --redirect __write=__write_user
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: M2S050 Microsemi M2S050
  ICCARM.CCIncludePath2: ../hal; ../hal/CortexM3; ../hal/CortexM3/EWARM; ../CMSIS; ../CMSIS/startup_iar; ../drivers; ../; ../app; ../user_drivers; ../os/include; ../os/portable; ../usr_lib/libcsp/include
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: TTC.srec
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Microsemi\M2S010.icf
  group (top)
    ./: README.txt
  group app
    ../app/: adc_task.c adc_task.h bsp.c bsp.h csp_task.c csp_task.h FreeRTOSConfig.h main.c pkg_cb.c pkg_cb.h rf_rx_task.c rf_rx_task.h rf_tx_task.c rf_tx_task.h
  group CMSIS
    ../CMSIS/startup_iar/: default_irqs.c low_level_init.c read.c startup_m2sxxx.s vector_table.c write.c
    ../CMSIS/: hw_reg_io.h m2sxxx.h mss_assert.h sys_init_cfg_types.h system_m2sxxx.c system_m2sxxx.h
  group DM
    ../usr_lib/DM/: dm.c dm.h dm_data_ttc.h dm_user.c
  group drivers
    ../drivers/mss_can/: mss_can.c mss_can.h
    ../drivers/mss_sys_services/: mss_comblk.c mss_comblk.h mss_comblk_page_handler.h mss_sys_services.c mss_sys_services.h
    ../drivers/mss_gpio/: mss_gpio.c mss_gpio.h
    ../drivers/mss_hpdma/: mss_hpdma.c mss_hpdma.h
    ../drivers/mss_i2c/: mss_i2c.c mss_i2c.h
    ../drivers/mss_nvm/: mss_nvm.c mss_nvm.h
    ../drivers/mss_pdma/: mss_pdma.c mss_pdma.h
    ../drivers/mss_spi/: mss_spi.c mss_spi.h
    ../drivers/mss_timer/: mss_timer.h
    ../drivers/mss_uart/: mss_uart.c mss_uart.h mss_uart_regs.h
    ../drivers/mss_watchdog/: mss_watchdog.h
  group drivers_config
    ../drivers_config/sys_config/: sys_config.c sys_config.h sys_config_mss_clocks.h
  group os
    ../os/: croutine.c event_groups.c list.c queue.c RunTimeStatsTimer.c tasks.c timers.c
  group os/include
    ../os/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group os/portable
    ../os/portable/: heap_4.c port.c portasm.s portmacro.h
  group user_drivers
    ../user_drivers/: APB3_reg.h ntc.c ntc.h ntc_smd.h ntc_thru.h ntc_ttc.h radio_rx_config.h radio_tx_config.h si4463.c si4463.h tlv2548.c tlv2548.h
  group usr_lib/libcsp/inc
    ../usr_lib/libcsp/include/csp/: csp.h csp_autoconfig.h csp_buffer.h csp_ccsds.h csp_cmp.h csp_crc32.h csp_debug.h csp_endian.h csp_error.h csp_iflist.h csp_interface.h csp_platform.h csp_rtable.h csp_types.h
  group usr_lib/libcsp/inc/arch
    ../usr_lib/libcsp/include/csp/arch/: csp_clock.h csp_malloc.h csp_queue.h csp_semaphore.h csp_system.h csp_thread.h csp_time.h
  group usr_lib/libcsp/inc/drivers
    ../usr_lib/libcsp/include/csp/drivers/: can.h tmp.h
  group usr_lib/libcsp/inc/interfaces
    ../usr_lib/libcsp/include/csp/interfaces/: csp_if_can.h csp_if_kiss.h csp_if_lo.h
  group usr_lib/libcsp/src
    ../usr_lib/libcsp/src/: csp_bridge.c csp_buffer.c csp_ccsds.c csp_conn.c csp_conn.h csp_crc32.c csp_debug.c csp_dedup.c csp_dedup.h csp_endian.c csp_iflist.c csp_io.c csp_io.h csp_port.c csp_port.h csp_promisc.c csp_promisc.h csp_qfifo.c csp_qfifo.h csp_route.c csp_route.h csp_service_handler.c csp_services.c csp_sfp.c
  group usr_lib/libcsp/src/arch
    ../usr_lib/libcsp/src/arch/freertos/: csp_malloc.c csp_queue.c csp_semaphore.c csp_system.c csp_thread.c csp_time.c
  group usr_lib/libcsp/src/crypto
    ../usr_lib/libcsp/src/crypto/: csp_hmac.c csp_hmac.h csp_sha1.c csp_sha1.h csp_xtea.c csp_xtea.h
  group usr_lib/libcsp/src/drivers
    ../usr_lib/libcsp/src/drivers/can/: can_m2sxxx.c can_m2sxxx.h
    ../usr_lib/libcsp/src/drivers/tmp/: tmp.c
  group usr_lib/libcsp/src/interfaces
    ../usr_lib/libcsp/src/interfaces/: csp_if_can.c csp_if_kiss.c csp_if_lo.c
  group usr_lib/libcsp/src/rtable
    ../usr_lib/libcsp/src/rtable/: csp_rtable_static.c
  group usr_lib/libcsp/src/transport
    ../usr_lib/libcsp/src/transport/: csp_rdp.c csp_transport.h csp_udp.c
  group usr_lib/rtt
    ../usr_lib/rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
