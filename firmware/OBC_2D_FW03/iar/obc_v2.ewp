# IAR project obc_v2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT; __FPU_USED
  ICCARM.CCDiagSuppress: Pa050,Pa082,Pe546
  ICCARM.CCIncludePath2: ../fwlib\stdlib\inc; ../fwlib\cmsis\st\inc; ../fwlib\cmsis\os; ../app; ../lib; ../devices\sdcard; ../devices\led; ../devices\spi_flash; ../devices\console; ../devices\ms5611; ../devices\magd; ../devices\imu; ../modules; ../modules\fat_fs; ../modules\usrlib; ../modules\libcsp\include; ../modules\rtt; ../modules\dm; ../modules\sfud\inc; ../modules\spiffs; ../modules\rzsz; ../modules\sysview; ../lib\Basic64; ../freertos\include; ../freertos\portable
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../app
  OBJCOPY.OOCOutputFile: obc_v2.hex
  ILINK.IlinkOutputFile: stm32f4lib.out
  ILINK.IlinkIcfFile: obc_v2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/: bsp.c bsp.h camshot_thread.c camshot_thread.h config.h fdr.c fdr.h FreeRTOSConfig.h ftp_thread.c ftp_thread.h imumagd.c imumagd.h main.c main.h memory_thread.c memory_thread.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group devices/console
    ../devices/console/: console.c console.h
  group devices/imu
    ../devices/imu/: adis16375.c adis16375.h
  group devices/led
    ../devices/led/: led_switch.c led_switch.h
  group devices/magd
    ../devices/magd/: LIS3MDL.c LIS3MDL.h
  group devices/sdcard
    ../../../../库模板/kc342daq/: binaryobjects.h
    ../devices/sdcard/: fprint.c fprint.h mark.c mark.h mfifo.h packet.c packet.h sd_spi_stm32.c sdcard.c sdcard.h serial_svc.c serial_svc.h thermocouple.c thermocouple.h
  group devices/spi_flash
    ../devices/spi_flash/: sfud_port.c spi_flash.c spi_flash.h
  group freertos
    ../freertos/: croutine.c event_groups.c heap_4.c list.c queue.c tasks.c timers.c
  group freertos/include
    ../freertos/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group freertos/portable
    ../freertos/portable/: port.c portasm.s portmacro.h
  group fwlib/cmsis
    ../fwlib/cmsis/st/src/: startup_stm32f40_41xxx.s system_stm32f4xx.c
    ../fwlib/cmsis/st/inc/: stm32f4xx.h system_stm32f4xx.h
  group fwlib/cmsis/dsplib
    ../fwlib/cmsis/dsplib/: arm_cortexM4lf_math.lib
  group fwlib/cmsis/os
    ../fwlib/cmsis/os/: cmsis_os.c cmsis_os.h cpu_utils.c cpu_utils.h
  group fwlib/stdlib
    ../fwlib/stdlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../fwlib/stdlib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group lib/AHRS
    ../lib/AHRS/: 3dmath_helper.h gradient_descent.c gradient_descent.h MadgwickAHRS.c MadgwickAHRS.h MahonyAHRS.c MahonyAHRS.h quater2euler.c quater2euler.h xyzlla.c xyzlla.h
  group lib/Basic64
    ../lib/Basic64/: Basic64.c Basic64.h
  group lib/UBX
    ../lib/UBX/: gps_ubx.c gps_ubx.h
  group modules/dm
    ../modules/dm/: dm.c dm.h dm_data_obc.h dm_user.c
  group modules/fat_fs
    ../modules/fat_fs/option/: ccsbcs.c syscall.c unicode.c
    ../modules/fat_fs/: diskio.h ff.c ff.h ffconf.h integer.h
  group modules/libcsp/include/csp
    ../modules/libcsp/include/csp/: csp.h csp_autoconfig.h csp_buffer.h csp_cmp.h csp_crc32.h csp_debug.h csp_endian.h csp_error.h csp_iflist.h csp_interface.h csp_platform.h csp_rtable.h csp_types.h
  group modules/libcsp/include/csp/arch
    ../modules/libcsp/include/csp/arch/: csp_clock.h csp_malloc.h csp_queue.h csp_semaphore.h csp_system.h csp_thread.h csp_time.h
  group modules/libcsp/include/csp/drivers
    ../modules/libcsp/include/csp/drivers/: can.h tmp.h
  group modules/libcsp/include/csp/interfaces
    ../modules/libcsp/include/csp/interfaces/: csp_if_can.h csp_if_kiss.h csp_if_lo.h
  group modules/libcsp/src
    ../modules/libcsp/src/: csp_bridge.c csp_buffer.c csp_conn.c csp_conn.h csp_crc32.c csp_debug.c csp_dedup.c csp_dedup.h csp_endian.c csp_iflist.c csp_io.c csp_io.h csp_port.c csp_port.h csp_promisc.c csp_promisc.h csp_qfifo.c csp_qfifo.h csp_route.c csp_route.h csp_service_handler.c csp_services.c csp_sfp.c
  group modules/libcsp/src/arch
    ../modules/libcsp/src/arch/freertos/: csp_malloc.c csp_queue.c csp_semaphore.c csp_system.c csp_thread.c csp_time.c
  group modules/libcsp/src/crypto
    ../modules/libcsp/src/crypto/: csp_hmac.c csp_hmac.h csp_sha1.c csp_sha1.h csp_xtea.c csp_xtea.h
  group modules/libcsp/src/drivers/can
    ../modules/libcsp/src/drivers/can/: can_stm32.c can_stm32.h
  group modules/libcsp/src/drivers/tmp
    ../modules/libcsp/src/drivers/tmp/: tmp.c
  group modules/libcsp/src/interfaces
    ../modules/libcsp/src/interfaces/: csp_if_can.c csp_if_kiss.c csp_if_lo.c
  group modules/libcsp/src/rtable
    ../modules/libcsp/src/rtable/: csp_rtable_static.c
  group modules/libcsp/src/transport
    ../modules/libcsp/src/transport/: csp_rdp.c csp_transport.h csp_udp.c
  group modules/rtt
    ../modules/rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group modules/rzsz
    ../modules/rzsz/: rzsz.c rzsz.h
  group modules/sfud/inc
    ../modules/sfud/inc/: sfud.h sfud_cfg.h sfud_def.h sfud_flash_def.h
  group modules/sfud/src
    ../modules/sfud/src/: sfud.c sfud_sfdp.c
  group modules/spiffs
    ../modules/spiffs/: spiffs.h spiffs_cache.c spiffs_check.c spiffs_config.h spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c spiffs_nucleus.h
  group modules/syscalls
    ../modules/syscalls/: syscall_printf.c
  group modules/sysview
    ../modules/sysview/: Global.h os_cfg_trace.h os_trace_events.h SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.h SEGGER_SYSVIEW_Int.h
  group modules/usrlib
    ../modules/usrlib/: datatypes.h debug.c debug.h dma.c dma.h metro.hpp os.h pin.c pin.h pin_define.h rtc.c rtc.h spi.c spi.h stm32f4_pwmicp.c stm32f4_pwmicp.h uart.c uart.h uart_custom_api.h
