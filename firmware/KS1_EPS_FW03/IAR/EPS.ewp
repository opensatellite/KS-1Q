# IAR project EPS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xB ST STM32F105xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../FWlib\STM32F10x_StdPeriph_Driver\inc; ../FWlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ../User; ../FWlib\CMSIS\CM3\CoreSupport; ../FWlib\CMSIS\OS; ../Freertos/include; ../Freertos/portable; ../modules; ../usr_lib; ../usr_lib/OD; ../usr_lib/dm; ../usr_lib/stm32f1; ../usr_lib/util; ../usr_lib/kcsanetworkttc; ../usr_lib/libcsp/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../User
  OBJCOPY.OOCOutputFile: EPS.hex
  ILINK.IlinkOutputFile: EPS.out
  ILINK.IlinkIcfFile: F:\科创航天\KS01_EPS_FW01\IAR\stm32f105xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group CMSIS
    ../FWlib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../FWlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../FWlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Freertos
    ../Freertos/: croutine.c event_groups.c heap_4.c list.c queue.c tasks.c timers.c
  group Freertos/include
    ../Freertos/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group Freertos/portable
    ../Freertos/portable/: port.c portasm.s portmacro.h
  group Fwlib
    ../FWlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../FWlib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Fwlib/OS
    ../FWlib/CMSIS/OS/: cmsis_os.c cmsis_os.h
  group modules
    ../modules/: ADXL345.c ADXL345.h ntc.c ntc.h ntc_smd.h ntc_thru.h tlv2548.c tlv2548.h
  group User
    ../User/: bsp.c bsp.h FreeRTOSConfig.h ledtlm.c ledtlm.h loop.c loop.h main.c stm32f10x_conf.h stm32f10x_it.c syscall_printf.c system.c
  group usr_lib/dm
    ../usr_lib/dm/: dm.c dm.h dm_data.h dm_user.c
  group usr_lib/kcsanetworkttc
    ../usr_lib/kcsanetworkttc/: 3dmath_helper.h binaryobjects.h cbinaryparser.c cbinaryparser.h
  group usr_lib/libcsp/include/csp
    ../usr_lib/libcsp/include/csp/: csp.h csp_autoconfig.h csp_buffer.h csp_ccsds.h csp_cmp.h csp_crc32.h csp_debug.h csp_endian.h csp_error.h csp_iflist.h csp_interface.h csp_platform.h csp_rtable.h csp_types.h
  group usr_lib/libcsp/include/csp/arch
    ../usr_lib/libcsp/include/csp/arch/: csp_clock.h csp_malloc.h csp_queue.h csp_semaphore.h csp_system.h csp_thread.h csp_time.h
  group usr_lib/libcsp/include/csp/drivers
    ../usr_lib/libcsp/include/csp/drivers/: can.h tmp.h
  group usr_lib/libcsp/include/csp/interfaces
    ../usr_lib/libcsp/include/csp/interfaces/: csp_if_can.h csp_if_kiss.h csp_if_lo.h
  group usr_lib/libcsp/src
    ../usr_lib/libcsp/src/: csp_bridge.c csp_buffer.c csp_conn.c csp_conn.h csp_crc32.c csp_debug.c csp_dedup.c csp_dedup.h csp_endian.c csp_iflist.c csp_io.c csp_io.h csp_port.c csp_port.h csp_promisc.c csp_promisc.h csp_qfifo.c csp_qfifo.h csp_route.c csp_route.h csp_service_handler.c csp_services.c csp_sfp.c
  group usr_lib/libcsp/src/arch
    ../usr_lib/libcsp/src/arch/freertos/: csp_malloc.c csp_queue.c csp_semaphore.c csp_system.c csp_thread.c csp_time.c
  group usr_lib/libcsp/src/crypto
    ../usr_lib/libcsp/src/crypto/: csp_hmac.c csp_hmac.h csp_sha1.c csp_sha1.h csp_xtea.c csp_xtea.h
  group usr_lib/libcsp/src/drivers
    ../usr_lib/libcsp/src/drivers/can/: can_stm32.c can_stm32.h
  group usr_lib/libcsp/src/interfaces
    ../usr_lib/libcsp/src/interfaces/: csp_if_can.c csp_if_kiss.c csp_if_lo.c
  group usr_lib/libcsp/src/rtable
    ../usr_lib/libcsp/src/rtable/: csp_rtable_static.c
  group usr_lib/libcsp/src/transport
    ../usr_lib/libcsp/src/transport/: csp_rdp.c csp_transport.h csp_udp.c
  group usr_lib/stm32f1
    ../usr_lib/stm32f1/: pin.c pin.h pin_define.h spi.c spi.h stm32_adc.c stm32_adc.h stm32_pwm.c stm32_pwm.h
  group usr_lib/util
    ../usr_lib/util/: datatypes.h debug.c debug.h delay.c delay.h macros.h mfifo.h vtimer.c vtimer.h
    ../usr_lib/stm32f1/: systick.c systick.h uart.c uart.h uart_custom_api.h
